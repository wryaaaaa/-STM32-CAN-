# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: firmware_gateway +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\common\cmsis;..\common\std_periph_lib;..\common\freertos;..\common\freertos\inc;..\common\freertos\port;..\common\freertos\src;..\common\drivers\can;..\common\drivers\usart;..\common\drivers\dht11;..\common\drivers\oled;..\common\drivers\esp8266;..\common\drivers\led;..\common\drivers\key;..\common\drivers\delay;..\common\utils\ring_buffer;..\common\utils\protocol;.\inc;.\src\tasks
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group common/cmsis
    ../common/cmsis/: startup_stm32f10x_md.s system_stm32f10x.c core_cm3.c
  group common/freertos
    ../common/freertos/port/: port.c heap_4.c
    ../common/freertos/src/: tasks.c queue.c list.c timers.c event_groups.c croutine.c
  group common/std_periph_lib
    ../common/std_periph_lib/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_can.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_exti.c misc.c
  group common/drivers
    ../common/drivers/can/: can_driver.c
    ../common/drivers/usart/: usart.c
    ../common/drivers/esp8266/: esp8266.c
    ../common/drivers/oled/: oled.c
    ../common/drivers/led/: led.c
    ../common/drivers/delay/: delay.c
    ../common/utils/ring_buffer/: ring_buffer.c
  group firmware_gateway/src
    ./src/: main.c stm32f10x_it.c
  group firmware_gateway/tasks
    ./src/tasks/: task_can_recv.c task_esp_upload.c task_oled_disp.c task_can_poll.c
